Commit message: himloco历史六帧观测

File: source/robot_lab/data/Robots/atdog/dog2/urdf/dog2.urdf (robot description, URDF)
Before this commit: robot dog2, 17 links, 16 joints
Links:
- link base: mass 6.236 -> 5.436
