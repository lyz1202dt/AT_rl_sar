Commit message: 修改Dog3无机械臂版本的URDF模型

File: source/robot_lab/data/Robots/atdog/dog3/urdf/dog3.urdf (robot description, URDF)
Before this commit: robot dog3, 17 links, 16 joints
Links:
- link base: mass 5.21190058620009 -> 5.314207
